options:
  parameters:
    generate_options: qt_gui
    id: my_id
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '10'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: howto_dumb_0
  id: howto_dumb
  parameters:
    muh_arg: '10'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', howto_dumb_0, '0']
- [howto_dumb_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
