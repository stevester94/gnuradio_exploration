options:
  parameters:
    author: steven
    generate_options: qt_gui
    id: amp_modulator
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '20'
    ymin: '-20'
  states: {}
- name: steves_amplitude_modulation_amplitude_modulator_0
  id: steves_amplitude_modulation_amplitude_modulator
  parameters:
    amp_carrier: '10'
    freq_carrier_Hz: '1000'
    samp_rate: samp_rate
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', steves_amplitude_modulation_amplitude_modulator_0, '0']
- [steves_amplitude_modulation_amplitude_modulator_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
