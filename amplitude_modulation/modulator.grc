options:
  parameters:
    author: steven
    generate_options: qt_gui
    id: amp_modulator
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: carrier_amp
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: lowpass_freq_Hz
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '100'
    stop: '20000'
    value: '2000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '500'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/steven/Downloads/onclassical_demo_demicheli_geminiani_pieces_allegro-in-f-major_small-version.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: lowpass_freq_Hz
    decim: '1'
    gain: '5'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: Baseband
    size: '10000'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: Filtered
    size: '10000'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: Passband
    size: '10000'
    srate: samp_rate
    type: float
  states: {}
- name: steves_amplitude_modulation_amplitude_modulator_0
  id: steves_amplitude_modulation_amplitude_modulator
  parameters:
    amp_carrier: carrier_amp
    freq_carrier_Hz: '15000'
    samp_rate: samp_rate
  states: {}
- name: steves_amplitude_modulation_rectifier_0
  id: steves_amplitude_modulation_rectifier
  parameters: {}
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_throttle_0, '0', steves_amplitude_modulation_amplitude_modulator_0, '0']
- [blocks_wavfile_source_0, '0', audio_sink_1, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [low_pass_filter_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0_0_0_0_0, '0']
- [steves_amplitude_modulation_amplitude_modulator_0, '0', qtgui_time_sink_x_0_0_0_0_0_0, '0']
- [steves_amplitude_modulation_amplitude_modulator_0, '0', steves_amplitude_modulation_rectifier_0, '0']
- [steves_amplitude_modulation_rectifier_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
