options:
  parameters:
    generate_options: qt_gui
    id: testing_flow
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '100'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: steves_amplitude_modulation_testing_0
  id: steves_amplitude_modulation_testing
  parameters:
    amp_multiplier: '10'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', steves_amplitude_modulation_testing_0, '0']
- [steves_amplitude_modulation_testing_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
